# Keil uVision project sounder32.uvprojx, settings and files
target sounder32 (6090000::V6.9::.\ARMCLANG)
  device: STM32C031K4Ux STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0x8000000-0x8003FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: sounder32 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32C031xx
  c include: ../Core/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application/MDK-ARM
    ./: startup_stm32c031xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_adc.c stm32c0xx_hal_adc_ex.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_cortex.c stm32c0xx_hal_exti.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
  group wrappers
    ../../../wrappers/: wrap.c wrap.h
  group sounder_source
    ../../../: ADC.c clock.c flash.c gpio.c I2C.c registers.c sounder.c stm8_interrupt_vector.c utils.c usart.c timers.c ADC.h I2C.h flash.h clock.h gpio.h registers.h sounder.h timers.h usart.h utils.h stm_header.h main_8.c
software components: CMSIS:CORE 5.1.1
